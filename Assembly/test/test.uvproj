# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: test
  c flags: Optim=1
  group Source Group 1
    ./: test.s
