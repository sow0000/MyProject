# Keil uVision project problem01.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: problem01
  c flags: Optim=1
  group Source Group 1
    ./: problem01.s
