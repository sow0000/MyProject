# Keil uVision project exercise03.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: exercise03
  c flags: Optim=1
  group Source Group 1
    ./: exercise03.s
