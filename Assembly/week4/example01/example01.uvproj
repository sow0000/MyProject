# Keil uVision project example01.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: example01
  c flags: Optim=1
  group Source Group 1
    ./: example01.s
